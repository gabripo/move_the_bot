Commit message: opc: introduce Moveit 2 Motion Planner

File: moveit_config/simple_arm.urdf (robot description, URDF)
Before this commit: robot simple_arm, 5 links, 4 joints
Joints:
- joint elbow_joint: limit lower=-2.5 upper=2.5 effort=1 velocity=1 -> lower=-2.0 upper=2.0 effort=1 velocity=1
